# Keil uVision project PanaFoc_G030K8T6.uvprojx, settings and files
target PanaFoc_G030K8T6 (6180000::V6.18::ARMCLANG)
  device: STM32G030K8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: PanaFoc_G030K8T6 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: ARM_MATH_CM0PLUS,USE_HAL_DRIVER,STM32G030xx
  c include: ../Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../MCSDK_v6.3.0-Full/MotorControl/MCSDK/MCLib/Any/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../RefgeFunction/Inc/app;../RefgeFunction/Inc/com;../RefgeFunction/Inc/hogo;../RefgeFunction/Inc/inv;../RefgeFunction/Inc/main;..\USERPhaseEstimator\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: PanaFoc_G030K8T6.sct
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c mc_config.c mc_config_common.c mc_tasks.c mc_tasks_foc.c pwm_curr_fdbk.c regular_conversion_manager.c mc_math.c mc_interface.c stm32_mc_common_it.c stm32g0xx_mc_it.c mc_parameters.c r1_ps_pwm_curr_fdbk.c mc_configuration_registers.c pwm_common.c mc_app_hooks.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Middlewares/MotorControl
    ../MCSDK_v6.3.0-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c flux_weakening_ctrl.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c sto_pll_speed_pos_fdbk.c virtual_speed_sensor.c max_torque_per_ampere.c
  group USERPhaseEstimator
    ../USERPhaseEstimator/Src/: filter.c Inv_fct.c led.c motor_error.c motor_process.c sto_volt_speed_pos_fdbk.c dead_zone_compensation.c
  group RefgeFunction/main
    ../RefgeFunction/Src/main/: system_ram.c Softr.c
  group RefgeFunction/inv
    ../RefgeFunction/Src/inv/: Adpdc.c brake.c InvCommonFunc.c Output_i.c pwm.c RefSpeed.c Timea.c lowspeed_ctrl.c
  group RefgeFunction/hogo
    ../RefgeFunction/Src/hogo/: Hogo.c
  group RefgeFunction/com
    ../RefgeFunction/Src/com/: Trans_Inv.c
  group RefgeFunction/app
    ../RefgeFunction/Src/app/: Inttm51.c Main_Pros.c Pcbchk.c Time_h.c Time_m.c Time_s.c
software components: CMSIS:CORE 5.6.0
